# Keil uVision project bootloader.uvproj, settings and files
target bootloader (ARM-ADS)
  device: STM32F103R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: bootloader
  c flags: Optim=1
  c misc: --c99
  c include: .\cmsis;.
  memory RVCT4: ROM 0x8000000 size 0x3c00
  memory RVCT9: RAM 0x20000000 size 0x5000
  group cmsis
    ./cmsis/: stm32f10x.h core_cm3.h core_cm3.c system_stm32f10x.h system_stm32f10x.c startup_stm32f10x_md.s misc.h misc.c stm32f10x_spi.h stm32f10x_spi.c stm32f10x_conf.h stm32f10x_rcc.h stm32f10x_rcc.c stm32f10x_flash.h stm32f10x_flash.c stm32f10x_gpio.h stm32f10x_gpio.c
  group bsp
    ./bsp/: bsp.c bsp.h led.c led.h rf.c rf.h rf_hal.c rf_hal.h time.c time.h
  group app
    ./: main.c
  group app_communication
    ./app/communication/: communication.c communication.h interface.h protocol.h receive.c receive.h transmit.c transmit.h
  group app_math
    ./app/math/: interface.h other.c other.h
  group app_refresher
    ./app/refresher/: interface.h refresher.h refresher.c flash_map.h
  group app_engine
    ./app/engine/: interface.h engine.h engine.c
