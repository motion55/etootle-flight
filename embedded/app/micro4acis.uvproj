# Keil uVision project micro4acis.uvproj, settings and files
target micro4acis (ARM-ADS)
  device: STM32F103V8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: micro4acis
  AfterMake: fromelf.exe --bin -o ..\output\app.bin ..\output\app\micro4acis.axf
  c flags: Optim=1 wLevel=2
  c define: MOTION_DRIVER_TARGET_STM32
  c misc: --c99
  c include: .\cmsis;.;..\drivers\data_link;..\etootle_board;..\etootle_board\bsp;.\bsp;.\bsp\dmp
  memory RVCT4: ROM 0x8004000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group cmsis
    ./cmsis/: core_cm3.c misc.c stm32f10x_conf.h core_cm3.h misc.h stm32f10x.h startup_stm32f10x_md.s system_stm32f10x.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_usart.c
  group bsp
    ./bsp/: led.c led.h bsp.c bsp.h time.h time.c i2c.h i2c.c mpu6050.c mpu6050.h i2c_1.c battery.c battery.h motor.c motor.h hmc5883.h hmc5883.c flash.h flash.c
  group main
    ./: main.c
    ../drivers/data_link/: ring_buffer.c uart_data_process.c
  group app_communication
    ./app/communication/: interface.h communication.c communication.h protocol.h transmit.c transmit.h receive.c receive.h cmd.c cmd.h
  group app_math
    ./app/math/: interface.h other.c other.h quaternion.c quaternion.h
  group app_sensor
    ./app/sensor/: interface.h sensor.c sensor.h
  group app_attitude
    ./app/attitude/: interface.h attitude.h attitude.c accfilter.h accfilter.c gyrfilter.h gyrfilter.c magfilter.h magfilter.c mix.h mix.c
  group app_control
    ./app/control/: interface.h control.h control.c pid.h pid.c
  group app_exception
    ./app/exception/: exception.c exception.h interface.h
  group app_status
    ./app/status/: interface.h status.h status.c
  group app_param
    ./app/param/: interface.h param.h param.c
  group common_bsp
    ../etootle_board/bsp/: rf.c rf_hal.c uart.c
  group dmp
    ./bsp/dmp/: inv_mpu_dmp_motion_driver.c inv_mpu.c
target micro4acis_dual (ARM-ADS)
  device: STM32F103V8 STMicroelectronics
  cpu: as above
  output: micro4acis_dual
  AfterMake: fromelf.exe --bin -o ..\output\app_dual.bin ..\output\app_dual\micro4acis_dual.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: RF_USE_ACK_PAYLOAD,MOTION_DRIVER_TARGET_STM32
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x8004000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x5000
target micro4acis_dmp_dual (ARM-ADS)
  device: STM32F103V8 STMicroelectronics
  cpu: as above
  output: micro4acis_dmp_dual
  AfterMake: fromelf.exe --bin -o ..\output\app_dmp_dual.bin ..\output\app_dmp_dual\micro4acis_dmp_dual.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: RF_USE_ACK_PAYLOAD,MOTION_DRIVER_TARGET_STM32,USE_DMP
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x8004000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x5000
