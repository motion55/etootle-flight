# Keil uVision project bootloader.uvproj, settings and files
target bootloader (ARM-ADS)
  device: STM32F103R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: bootloader
  c flags: Optim=4
  c misc: --c99
  c include: .\cmsis;.;..\drivers\data_link;.\bsp;..\etootle_board;..\etootle_board\bsp
  memory RVCT4: ROM 0x8000000 size 0x3c00
  memory RVCT9: RAM 0x20000000 size 0x5000
  group cmsis
    ./cmsis/: stm32f10x.h core_cm3.h core_cm3.c system_stm32f10x.h system_stm32f10x.c startup_stm32f10x_md.s misc.h misc.c stm32f10x_spi.h stm32f10x_spi.c stm32f10x_conf.h stm32f10x_rcc.h stm32f10x_rcc.c stm32f10x_flash.h stm32f10x_flash.c stm32f10x_gpio.h stm32f10x_gpio.c stm32f10x_dma.c stm32f10x_usart.c
  group bsp
    ./bsp/: bsp.c bsp.h led.c led.h time.c time.h
  group app
    ./: main.c
    ../drivers/data_link/: uart_data_process.c ring_buffer.c
  group app_communication
    ./app/communication/: communication.c communication.h interface.h protocol.h receive.c receive.h transmit.c transmit.h
  group app_math
    ./app/math/: interface.h other.c other.h
  group app_refresher
    ./app/refresher/: interface.h refresher.h refresher.c flash_map.h
  group app_engine
    ./app/engine/: interface.h engine.h engine.c
  group common_bsp
    ../etootle_board/bsp/: rf.c rf_hal.c uart.c
target bootloader_dual (ARM-ADS)
  device: STM32F103R8 STMicroelectronics
  cpu: as above
  output: bootloader_dual
  c flags: Optim=4
  c define: RF_USE_ACK_PAYLOAD
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x3c00
  memory RVCT9: RAM 0x20000000 size 0x5000
