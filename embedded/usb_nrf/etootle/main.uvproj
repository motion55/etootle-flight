# Keil uVision project main.uvproj, settings and files
target usb_nrf (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: usb_nrf +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,HSE_VALUE=16000000
  c include: .;.\bsp;..\..\drivers\24l01;..\..\drivers\data_link;..\..\library\CMSIS\Device\ST\STM32F10x;..\..\library\CMSIS\Include;..\..\library\STM32F10x_StdPeriph_Driver\inc;..\..\library\STM32_USB-FS-Device_Driver\inc;..\..\drivers\usb_hid\stm32_fs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ./: main.c hw_config.c
    ../../drivers/data_link/: ring_buffer.c
  group System
    ./: system_stm32f10x_HSE_16MHz_sys_72MHz.c
    ../../library/CMSIS/Device/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group Drivers
    ../../drivers/24l01/: nrf24l01.c
  group bsp
    ./bsp/: bsp.c gpio.c spi.c
  group STM32F30x_StdPeriph_Driver
    ../../library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_usart.c
  group STM32_USB-FS-Device_Driver
    ../../library/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group usb_hid
    ../../drivers/usb_hid/stm32_fs/: usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
target usb_nrf_dual (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: as above
  output: usb_nrf_dual +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,HSE_VALUE=16000000,RF_USE_ACK_PAYLOAD
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
